<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\newtask4.s43</path>
  </project>
  <batchBuild/>
</workspace>


